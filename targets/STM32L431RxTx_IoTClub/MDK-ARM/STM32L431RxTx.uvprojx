# Keil uVision project STM32L431RxTx.uvprojx, settings and files
target Huawei_LiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Inc;..\..\..\drivers\third_party\ST\STM32L4xx_HAL_Driver\Inc;..\..\..\drivers\third_party\ST\STM32L4xx_HAL_Driver\Inc\Legacy;..\Hardware\OLED;..\Hardware\BC95;..\Hardware\BH1750;..\Hardware\DHT11;..\Hardware\GPS;..\..\..\components\cmsis;..\..\..\components\cmsis\1.0;..\..\..\components\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\arm-m\cortex-m4;..\..\..\examples\include;..\OS_CONFIG;..\..\..\components\at;..\..\..\components\osport;..\..\..\components\shell;..\..\..\include;..\..\..\include\osdepends\liteos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\STM32L431RCTx-LiteOS.sct
  group Application/MDK-ARM
    ./: los_startup_keil.s
  group Drivers/CMSIS
    ..//Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: gpio.c delay.c i2c.c adc.c sys_init.c
  group Hardware
    ../Hardware/OLED/: oled.c
    ../Hardware/BH1750/: BH1750.c
    ../Hardware/DHT11/: DHT11_BUS.c
    ../Hardware/GPS/: gps.c
  group liteos/cmsis
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/common/: los_slab.c los_slabmem.c los_memcheck.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
    ../../../kernel/base/mem/membox/: los_membox.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group user
    ../Src/: usart.c main.c
    ../AppDrive/: app.c bc95.c uart_at.c uart_debug.c
  group at
    ../../../components/at/: at.c
  group osport
    ../../../components/osport/: iodev.c mem.c mutex.c ring.c sem.c string.c task.c
  group shell
    ../../../components/shell/: shell_cmd.c shell_main.c shell_test.c
  group osconfig
    ../OS_CONFIG/: los_builddef.h los_printf.h target_config.h
  group STM32L4xx_HAL_Driver
    ../../../drivers/third_party/ST/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c
software components: CMSIS:CORE 5.1.1
